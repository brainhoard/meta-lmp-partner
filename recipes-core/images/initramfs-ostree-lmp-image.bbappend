#@TYPE: Image
#@NAME: LMP Initramfs
#@DESCRIPTION: LMP Initramfs

PACKAGE_INSTALL:append = " \
    cryptsetup \
"
